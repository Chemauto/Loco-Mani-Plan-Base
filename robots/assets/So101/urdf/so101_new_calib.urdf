Commit message: add so101 rl

File: robots/assets/So101/urdf/so101_new_calib.urdf (robot description, URDF)
Before this commit: robot so101_new_calib, 8 links, 7 joints
Links:
- link gripper_frame_link: geometry visual box size=0.001 0.001 0.001
